include tttech-license.inc
