FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

export SGML_CATALOG_FILES="file://${STAGING_ETCDIR_NATIVE}/xml/catalog"
