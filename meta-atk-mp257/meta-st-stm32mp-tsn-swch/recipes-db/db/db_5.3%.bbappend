DB5_CONFIG = "--enable-o_direct --disable-cryptography --disable-queue --disable-replication --disable-verify --enable-compat185 --disable-sql"
