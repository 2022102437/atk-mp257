# Copyright (C) 2026 Christophe Priouzeau <christophe.priouzeau@foss.st.com>
# Released under the MIT license (see COPYING.MIT for the terms)

SUMMARY = ""
HOMEPAGE = ""
LICENSE = ""
SECTION = ""
DEPENDS = ""

SRC_URI = ""
